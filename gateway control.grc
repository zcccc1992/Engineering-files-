options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cf
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: minus
  id: variable
  parameters:
    value: '-np.zeros (period // 2, dtype=np.float32)'
  states: {}
- name: ones
  id: variable
  parameters:
    value: np.ones (period // 2, dtype=np.float32)
  states: {}
- name: period
  id: variable
  parameters:
    value: int(samp_rate / 1e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: wave6
  id: variable
  parameters:
    value: np.tile(np.hstack([ones, minus]), 8)
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '10000'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"tx_chirp"'
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: wave6
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '10000'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      import numpy as np
      from gnuradio import gr
      import pmt

      import numpy as np
      from gnuradio import gr
      import pmt

      import numpy as np
      from gnuradio import gr
      import pmt

      class BitCounter(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="BitCounter",
                  in_sig=[np.complex64],
                  out_sig=[np.int8])
              self.n_ones = 0
              self.last   = 0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              n   = len(in0)
              out[:n] = in0   
              for i, x in enumerate(in0):
                  mag = 1 if abs(x) > 0.5 else 0 
                  if mag and not self.last: 
                      self.n_ones += 1
                      self.add_item_tag(0, self.nitems_written(0) + i,
                                        pmt.intern('bit_cnt'),
                                        pmt.from_long(self.n_ones))
                  self.last = mag  
              return n
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class ChirpTrigger(gr.sync_block):
          def __init__(self, target=6):
              gr.sync_block.__init__(self,
                  name="ChirpTrigger",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.target = target
          def work(self, input_items, output_items):
              n = len(input_items[0])
              tags = self.get_tags_in_range(0, self.nitems_read(0),
                                            self.nitems_read(0)+n)
              for tag in tags:
                  if pmt.eq(tag.key, pmt.intern('bit_cnt')):
                      cnt = pmt.to_long(tag.value)
                      if cnt >= self.target:
                          self.add_item_tag(0, tag.offset,
                                            pmt.intern('tx_chirp'),
                                            pmt.from_bool(True))
              output_items[0][:n] = input_items[0]
              return n
    target: '6'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class ChirpGen(gr.sync_block):
          def __init__(self, samp_rate=1e6, f0=100e3, f1=400e3, duration=10e-3):
              gr.sync_block.__init__(self,
                  name="ChirpGen",
                  in_sig=[np.int8],
                  out_sig=[np.complex64])
              self.samp_rate = samp_rate
              self.f0, self.f1, self.T = f0, f1, duration
              self.chirp = self._make_chirp()
              self.tx_left = 0
              self.cycling = False 
              self.idx = 0 
          def _make_chirp(self):
              N = int(self.T*self.samp_rate)
              t = np.arange(N)/self.samp_rate
              k = (self.f1-self.f0)/self.T
              return np.exp(1j*2*np.pi*(self.f0*t + 0.5*k*t*t)).astype(np.complex64)
          def work(self, input_items, output_items):
              n = len(output_items[0])
              out = output_items[0]

              tags = self.get_tags_in_range(0, self.nitems_read(0),
                                          self.nitems_read(0) + n)
              for tag in tags:
                  if pmt.eq(tag.key, pmt.intern('tx_chirp')):
                      print('ChirpGen: got tx_chirp @ offset', self.nitems_read(0))
                      self.cycling = True
                      break

              if self.cycling:
                  print('ChirpGen: emitting', n, 'samples, idx=', self.idx)
                  for i in range(n):
                      out[i] = self.chirp[self.idx]
                      self.idx = (self.idx + 1) % len(self.chirp)
              else:
                  out[:] = 1

              return n
    duration: '0.001'
    f0: '100000.0'
    f1: '400000.0'
    samp_rate: samp_rate
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class RefChirp(gr.sync_block):
          def __init__(self, samp_rate=1e6, f0=100e3, f1=400e3, duration=10e-3):
              gr.sync_block.__init__(self,
                  name="RefChirp",
                  in_sig=[np.uint8],
                  out_sig=[np.complex64])
              N = int(duration*samp_rate)
              t = np.arange(N)/samp_rate
              k = (f1-f0)/duration
              self.chirp = np.exp(1j*2*np.pi*(f0*t + 0.5*k*t*t)).astype(np.complex64)
              self.idx = 0
              self.pass_through = False 
          def work(self, input_items, output_items):
              n = len(output_items[0])
              out = output_items[0]
              M = len(self.chirp)
              tags = self.get_tags_in_range(1, self.nitems_read(1),
                                            self.nitems_read(1)+n)
              for tag in tags:
                  if pmt.eq(tag.key, pmt.intern('tx_chirp')):
                      self.pass_through = True
                      break
              if self.pass_through:
                  for i in range(n):
                      out[i] = self.chirp[self.idx]
                      self.idx = (self.idx+1) % M
              else:
                  out[:] = 1
              return n
    duration: '10e-3'
    f0: 400e3
    f1: 100e3
    samp_rate: samp_rate
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np, zmq, pmt, json
      from gnuradio import gr


      class PeakDetector(gr.sync_block):
          def __init__(self, samp_rate=1e6, fft_size=2048):
              gr.sync_block.__init__(
                  self,
                  name="PeakDetector",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32] 
              )
              self.samp_rate = samp_rate
              self.fft_size = fft_size
              self.window = np.blackman(fft_size)
              self.buf = np.zeros(fft_size, dtype=np.complex64)
              self.cnt = 0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n_in = len(in0)

              out_val = output_items[0]   # peak magnitude
              out_freq = output_items[1]  # peak frequency
              n_out = len(out_val)    

              produced = 0     

              for i in range(n_in):
                  self.buf[self.cnt] = in0[i]
                  self.cnt += 1

                  if self.cnt == self.fft_size:
                      spec = np.fft.fft(self.buf * self.window)
                      mag = np.abs(spec)
                      idx = int(np.argmax(mag))

                      peak_freq = idx * self.samp_rate / self.fft_size
                      if idx > self.fft_size // 2:
                          peak_freq -= self.samp_rate

                      if produced < n_out:
                          out_val[produced] = float(mag[idx])
                          out_freq[produced] = float(peak_freq)
                          produced += 1

                      self.cnt = 0

              self.produce(0, produced)  
              self.produce(1, produced)
              return n_in  
    fft_size: '10000'
    samp_rate: samp_rate
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class ChirpGate(gr.sync_block):
          def __init__(self, item_size=gr.sizeof_gr_complex):
              gr.sync_block.__init__(self,
                  name="ChirpGate",
                  in_sig=[np.complex64, np.uint8],
                  out_sig=[np.complex64])
              self.pass_through = False 

          def work(self, input_items, output_items):
              n = len(output_items[0])
              data_in = input_items[0]
              trig_in = input_items[1] 
              out     = output_items[0]

              tags = self.get_tags_in_range(1, self.nitems_read(1),
                                            self.nitems_read(1)+n)
              for tag in tags:
                  if pmt.eq(tag.key, pmt.intern('tx_chirp')):
                      self.pass_through = True
                      break

              if self.pass_through:
                  out[:] = data_in[:n]
              else:
                  out[:] = 1
              return n
    item_size: '8'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '10000'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: cutoff/4
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '5'
    min: '-5'
    type: byte
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"1"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: cf
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: cf
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:6666
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_multiply_xx_0, '0', low_pass_filter_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_tag_gate_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_0, '0', blocks_tag_gate_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_5, '0']
- [blocks_vector_to_stream_0, '0', epy_block_4, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', blocks_tag_debug_0, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_1, '0', epy_block_3, '0']
- [epy_block_1, '0', epy_block_5, '1']
- [epy_block_1, '0', qtgui_number_sink_1, '0']
- [epy_block_2, '0', qtgui_sink_x_0_0, '0']
- [epy_block_2, '0', uhd_usrp_sink_0, '0']
- [epy_block_3, '0', blocks_multiply_xx_0, '0']
- [epy_block_4, '0', qtgui_number_sink_0, '0']
- [epy_block_4, '0', zeromq_pub_sink_0, '0']
- [epy_block_4, '1', qtgui_number_sink_0_0, '0']
- [epy_block_4, '1', zeromq_pub_sink_0_0, '0']
- [epy_block_5, '0', blocks_multiply_xx_0, '1']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [low_pass_filter_1, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', blocks_tag_gate_0, '0']
- [uhd_usrp_source_0, '0', epy_block_5, '0']

metadata:
  file_format: 1
